inherit core-image-base
IMAGE_INSTALL_append = " final-project"
CORE_IMAGE_EXTRA_INSTALL += " uartserver"
